# Keil uVision project ucos_stm32f4.uvprojx, settings and files
target ucos_stm32f4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos_stm32f4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,_CC_ARM,__VFP_FP__,__FPU_PRESENT=1
  c include: ..\fwlib\inc;..\misis;..\task;..\ucos_II\Ports;..\ucos_II\Source;..\user;..\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c sys_cfg.c
  group ucos_task
    ../task/: task_start.c task_led.c task_receiver.c task_scan.c task_attitude.c
  group ucos_port
    ../ucos_II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos_core
    ../ucos_II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group misis
    ../misis/: system_stm32f4xx.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group hardware
    ../hardware/: LED.c LED.h systick.c systick.h MOTOR.c MOTOR.h OLED.c OLED.h OLED_Font.h PWM.c PWM.h key.c key.h bluetooth.c bluetooth.h gy86.c gy86.h comm.c comm.h alldata.h imu.c imu.h iic.c iic.h PID.c PID.h
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1
